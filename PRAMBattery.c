/* 	This program is used to check to see if the PRAM battery in this macintosh
	has died or not. It does this by seeing if the date is set to sometime in the 
	past, which I take to be before 1999. Since I live in the Future
	
	Programmer: 	Jeff Luszcz
	Started:		February 17, 1999
	Last Modified:	April 24, 1999
	
*/


/* removed from prefs prefixes file 
MacHeaders.h
*/

#include <Types.h>
#include <Events.h>
#include <Dialogs.h>	
#include <DateTimeUtils.h>	// for the date functions
#include <Sound.h>
#include <Fonts.h>


int kAlertID = 128;
#define kMoveToFront  (WindowPtr)-1L

/* Globals */
Rect	windRect;
	
/* Prototypes */
void Initialize(void);


// 
//	Main body of program SillyBalls
//

  unsigned long  	seconds;
  DateTimeRec    	date;
  short 			itemHit;
  DialogPtr			dialog;
  Boolean			dialogDone = false;
  EventRecord		event;
  
//MW specified argument and return type.
int main(void)
{
	Initialize();


	GetDateTime(&seconds);
	SecondsToDate(seconds, &date);
  
  	// if the year is less than 1999 then the battery could be dead
  	if ( date.year < 1999 ) {
  
 	 	// show the dead PRAM battery alert
		dialog = GetNewDialog( kAlertID, nil, kMoveToFront);
		SetDialogDefaultItem( dialog, ok );
		SetDialogTracksCursor( dialog, true);
		ShowWindow( dialog );
		SetPort( dialog);
	
		// wait till the user hits the ok button and the close the dialog
		dialogDone = false;
		while ( ! dialogDone ) {
			ModalDialog( nil, &itemHit );
			
			switch (itemHit) {
				case ok:
					dialogDone = true;
					break;
			}	
			// give some time to other processes
			WaitNextEvent( everyEvent, &event, 60L, nil );		
		}
		DisposeDialog( dialog );
	}
	return 0;	
}

// 
//	Initialize everything for the program, make sure we can run
//

//MW specified argument and return type.
void Initialize(void)
{
	/*
	OSErr		error;
	SysEnvRec	theWorld;
		
	//
	//	Test the computer to be sure we can do color.  
	//	If not we would crash, which would be bad.  
	//	If we canÕt run, just beep and exit.
	//
/*
	error = SysEnvirons(1, &theWorld);
	if (theWorld.hasColorQD == false) {
		SysBeep(50);
		ExitToShell();					// If no color QD, we must leave. 
	} */
	
	/* Initialize all the needed managers. */
	InitGraf(&qd.thePort); 
	InitFonts();
	InitWindows();
	InitMenus();
/*	TEInit(); */
	InitDialogs(nil);
	InitCursor();
}



